# IAR project MSD_FAT_FS_GENERIC_TEST.ewp, settings and files
configuration Flash Debug K40 (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TWR_K40X256
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\host_common; ..\..\..\..\source\classes; ..\..\..\..\source\classes\cdc; ..\..\..\..\source\classes\hid; ..\..\..\..\source\classes\hub; ..\..\..\..\source\classes\msd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: MSD_FAT_FS_GENERIC_TEST.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK40N512VMD100_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../common/: poll.c poll.h
    ./: readme.txt
  group app
    ../../: fattest.c main.c testcase.c
    ../../../common/kinetis/: printf.c rtc_kinetis.c sci_kinetis.c
  group app/fatfs
    ../../: ccsbcs.c diskio.c diskio.h ff.c ff.h
  group bsp/P2
    ../../../../source/bsp/P2/: P2.c
  group class
    ../../../../source/classes/common/: usb_classes.c
  group class/hub
    ../../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
  group class/msd
    ../../../../source/classes/msd/: usb_host_msd_bo.c usb_host_msd_queue.c usb_host_msd_ufi.c
  group driver
    ../../../../source/driver/kinetis/: khci_kinetis.c
    ../../../../source/driver/: mem_util.c usbevent.c usbmsgq.c usbsem.c
  group host_common
    ../../../../source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group linker_config
    ../../../common/kinetis/iar_ew/: MK40N512VMD100_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
