# IAR project MSD_FAT_FS_GENERIC_TEST.ewp, settings and files
configuration Flash Debug K70 (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TWR_K70FN1M0
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\driver\kinetis\ehci; ..\..\..\..\source\common; ..\..\..\..\source\host_common; ..\..\..\..\source\classes; ..\..\..\..\source\classes\hub; ..\..\..\..\source\classes\msd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK70FN1M0_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    ../../: fattest.c main.c testcase.c
    ../../../common/kinetis/: PIT1_kinetis.c printf.c sci_kinetis.c
    ../../../common/: poll.c poll.h
  group app/fatfs
    ../../: ccsbcs.c diskio.c diskio.h ff.c ff.h ffconf.h
  group bsp/P3
    ../../../../source/bsp/P3/: P3.c
  group class
    ../../../../source/classes/common/: usb_classes.c
  group class/hub
    ../../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
  group class/msd
    ../../../../source/classes/msd/: usb_host_msd_bo.c usb_host_msd_queue.c usb_host_msd_ufi.c
  group driver
    ../../../../source/driver/: mem_util.c usbevent.c usbmsgq.c usbsem.c
  group driver/ehci
    ../../../../source/driver/kinetis/ehci/: ehci_bw.c ehci_cncl.c ehci_intr.c ehci_iso.c ehci_main.c ehci_shut.c ehci_utl.c
  group driver/khci
    ../../../../source/driver/kinetis/: khci_kinetis.c
  group host_common
    ../../../../source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK70FN1M0_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
