<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSD_FAT_FS_GENERIC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>MSD_FAT_FS_GENERIC</project>
        <configuration>Flash Debug K40</configuration>
      </member>            
    </batchDefinition>
  </batchBuild>
</workspace>
