<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBH_HIDKBD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USBH_HIDKBD</project>
        <configuration>Flash Debug K20D7</configuration>
      </member>      
    </batchDefinition>
  </batchBuild>
</workspace>
