# Keil uVision project USBH_MOUSE.uvproj, settings and files
target K20D7 - Flash (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: USBH_MOUSE
  c flags: Optim=1 wLevel=1
  c define: TWR_K20D72M
  c include: ..\..\..\mouse;..\..\..\..\common;..\..\..\..\common\kinetis;..\..\..\..\..\source\classes\hid;..\..\..\..\..\source\classes\hub;..\..\..\..\..\source\driver;..\..\..\..\..\source\host_common;..\kinetis_k20_72MHz
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group StartUp
    ./: system_MK20DX256VLL7.c startup_MK20DX256VLL7.s
  group Documentation
    ./: Abstract.txt
  group bsp
    ../../../../../source/bsp/P1/: P1.c
  group app
    ../../../../common/: poll.c
    ../../../../common/kinetis/: PIT1_kinetis.c sci_kinetis.c
    ./: Retarget.c
    ../../: hidmouse.c
  group host_common
    ../../../../../source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group classes
    ../../../../../source/classes/common/: usb_classes.c
    ../../../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
    ../../../../../source/classes/hid/: usb_host_hid.c
  group driver
    ../../../../../source/driver/: usbmsgq.c usbsem.c usbevent.c mem_util.c
    ../../../../../source/driver/kinetis/: khci_kinetis.c
target K20D7 - RAM (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: USBH_MOUSE
  c flags: Optim=1
  c define: TWR_K20D72M
  c include: as above
  asm include: ..\..\..\keyboard;..\..\..\..\common;..\..\..\..\common\kinetis;..\..\..\..\..\source\classes\hid;..\..\..\..\..\source\classes\hub;..\..\..\..\..\source\driver;..\..\..\..\..\source\host_common;..\kinetis_k20_72MHz
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
