# IAR project USBH_Mouse.ewp, settings and files
configuration Flash Debug K21 (ARM, debug)
  General.OGChipSelectEditMenu: MK21DN512xxx5 Freescale MK21DN512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TWR_K21D50M
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\..\common; ..\..\..\..\common\kinetis; ..\..\..\..\..\source\driver; ..\..\..\..\..\source\driver\kinetis; ..\..\..\..\..\source\common; ..\..\..\..\..\source\host_common; ..\..\..\..\..\source\classes; ..\..\..\..\..\source\classes\hub; ..\..\..\..\..\source\classes\hid; E:\Project\06_07_K21 in IAR\Freescale USB Stack v4.0.0\Source_\Host\examples\hid\mouse
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_Mouse.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\common\kinetis\iar_ew\MK21DN512VL_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    ../../: hidmouse.c
    ../../../../common/kinetis/: PIT1_kinetis.c printf.c sci_kinetis.c
    ../../../../common/: poll.c poll.h
  group bsp
    ../../../../../source/bsp/K20_512/: K20_512.c
  group class
    ../../../../../source/classes/common/: usb_classes.c
  group class/hid
    ../../../../../source/classes/hid/: usb_host_hid.c
  group class/hub
    ../../../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
  group driver
    ../../../../../source/driver/kinetis/: khci_kinetis.c
    ../../../../../source/driver/: mem_util.c usbevent.c usbmsgq.c usbsem.c
  group host_common
    ../../../../../source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group linker config
    ../../../../common/kinetis/iar_ew/: MK21DN512VL_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
