# IAR project USBH_PRINTER.ewp, settings and files
configuration Flash Debug K53 (ARM, debug)
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TWR_K53N512
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\host_common; ..\..\..\..\source\classes; ..\..\..\..\source\classes\hub; ..\..\..\..\source\classes\printer
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK53N512CMD100_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug K53 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K53Xxxx Freescale K53Xxxx
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK53N512CMD100_RAM.icf
  group (top)
    ./: readme.txt
  group app
    ../../: menu_printer.c printer.c
    ../../../common/kinetis/: PIT1_kinetis.c printf.c sci_kinetis.c
    ../../../common/: poll.c poll.h
  group bsp/P2
    ../../../../source/bsp/P2/: P2.c
  group class
    ../../../../source/classes/common/: usb_classes.c
  group class/hub
    ../../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
  group class/printer
    ../../../../source/classes/printer/: usb_host_printer.c usb_host_printer_pcl5.c usb_host_printer_postscript.c usb_printer_language_common.c
  group driver
    ../../../../source/driver/kinetis/: khci_kinetis.c
    ../../../../source/driver/: mem_util.c usbevent.c usbmsgq.c usbsem.c
  group host_common
    ../../../../source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK53N512CMD100_Flash.icf MK53N512CMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
