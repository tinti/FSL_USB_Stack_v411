# IAR project USB_PRINTER.ewp, settings and files
configuration Flash Debug K20D7 (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx7 Freescale MK20DX256xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TWR_K20D72M
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\host_common; ..\..\..\..\source\classes; ..\..\..\..\source\classes\printer; ..\..\..\..\source\classes\hub
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK20DX256VLL7_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    ../../: menu_printer.c printer.c
    ../../../common/kinetis/: PIT1_kinetis.c printf.c sci_kinetis.c
    ../../../common/: poll.c poll.h
  group bsp/P1
    ../../../../Source/bsp/P1/: P1.c
  group class
    ../../../../Source/classes/common/: usb_classes.c
  group class/hub
    ../../../../Source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
  group class/printer
    ../../../../Source/classes/printer/: usb_host_printer.c usb_host_printer_pcl5.c usb_host_printer_postscript.c usb_printer_language_common.c
  group driver
    ../../../../Source/driver/kinetis/: khci_kinetis.c
    ../../../../source/driver/: mem_util.c usbevent.c
    ../../../../Source/driver/: usbmsgq.c usbsem.c
  group host_common
    ../../../../Source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK20DX256VLL7_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
