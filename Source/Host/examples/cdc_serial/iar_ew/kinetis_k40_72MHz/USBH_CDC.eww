<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBH_CDC.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USBH_CDC</project>
        <configuration>Flash Debug K20</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


