<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBH_MSD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USBH_MSD</project>
        <configuration>Flash Debug K21</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


