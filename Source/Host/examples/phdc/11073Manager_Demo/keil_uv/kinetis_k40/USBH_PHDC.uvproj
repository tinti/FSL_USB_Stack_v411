# Keil uVision project USBH_PHDC.uvproj, settings and files
target K40N512 - Flash (ARM-ADS)
  device: MK40N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: USBH_PHDC
  c flags: Optim=1 wLevel=1
  c define: TWR_K40X256,LITTLE_ENDIAN
  c include: ..\..\..\11073Manager_Demo;..\..\..\..\common;..\..\..\..\common\kinetis;..\..\..\..\..\source\classes\phdc;..\..\..\..\..\source\classes\hub;..\..\..\..\..\source\driver;..\..\..\..\..\source\host_common;..\kinetis_k40;..\..\..\..\..\source\classes\common
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_MK40N512VMD100.s system_MK40N512VMD100.c
  group Documentation
    ./: Abstract.txt
  group bsp
    ../../../../../source/bsp/P2/: P2.c
  group app
    ../../../../common/: poll.c
    ../../../../common/kinetis/: PIT1_kinetis.c sci.c
    ./: Retarget.c
    ../../: ieee11073_nom_strings.c framework.c phdcmng.c
  group host_common
    ../../../../../source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group classes
    ../../../../../source/classes/common/: usb_classes.c
    ../../../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
    ../../../../../source/classes/phdc/: usb_host_phdc.c
  group driver
    ../../../../../source/driver/: usbmsgq.c usbsem.c usbevent.c mem_util.c
    ../../../../../source/driver/kinetis/: khci_kinetis.c
target K40N512 - RAM (ARM-ADS)
  device: MK40N512VMD100 Freescale Semiconductor
  cpu: as above
  output: USBH_PHDC
  c flags: Optim=1 wLevel=1
  c define: TWR_K40X256,LITTLE_ENDIAN
  c include: ..\..\..\11073Manager_Demo;..\..\..\..\common;..\..\..\..\common\kinetis;..\..\..\..\..\source\classes\phdc;..\..\..\..\..\source\classes\hub;..\..\..\..\..\source\driver;..\..\..\..\..\source\host_common;..\kinetis_k40
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
