# IAR project USBH_PHDC.ewp, settings and files
configuration FLASH Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TWR_MKL25Z128; LITTLE_ENDIAN
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\..\common; ..\..\..\..\common\kinetis; ..\..\..\..\..\source\driver; ..\..\..\..\..\source\driver\kinetis; ..\..\..\..\..\source\common; ..\..\..\..\..\source\host_common; ..\..\..\..\..\source\classes; ..\..\..\..\..\source\classes\hub; ..\..\..\..\..\source\classes\phdc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_HID.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\common\kinetis\iar_ew\MKL25Z128xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../: framework.c ieee11073_nom_strings.c phdcmng.c
    ../../../../common/kinetis/: PIT1_kinetis.c printf.c sci_kinetis.c
    ../../../../common/: poll.c poll.h
  group bsp
    ../../../../../source/bsp/L2K/: L2K.c
  group class
    ../../../../../source/classes/common/: usb_classes.c
  group class/phdc
    ../../../../../source/classes/phdc/: usb_host_phdc.c
  group class/hub
    ../../../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
  group driver
    ../../../../../source/driver/kinetis/: khci_kinetis.c
    ../../../../../source/driver/: mem_util.c usbevent.c usbmsgq.c usbsem.c
  group host_common
    ../../../../../source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group linker config
    ../../../../common/kinetis/iar_ew/: MKL25Z128xxx4.icf
  group startup
    ./: cstartup_M.s low_level_init.c
