<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_AUDIO_GEN.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_AUDIO_GEN</project>
        <configuration>Flash Debug K40D7</configuration>
      </member>      
    </batchDefinition>
  </batchBuild>
</workspace>


