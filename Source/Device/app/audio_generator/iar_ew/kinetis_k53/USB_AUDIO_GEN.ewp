# IAR project USB_AUDIO_GEN.ewp, settings and files
configuration Flash Debug K53 (ARM, debug)
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K53N512
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK53N512CMD100_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug K53 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K53Xxxx Freescale K53Xxxx
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK53N512CMD100_RAM.icf
  group (top)
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: printf.c RealTimerCounter_kinetis.c sci.c wdt_kinetis.c
    ../../: usb_descriptor.c
  group class
    ../../: audio_data.c audio_generator.c
    ../../../../source/class/: usb_audio.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK53N512CMD100_Flash.icf MK53N512CMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
