# Keil uVision project USB_PHDC_MULTI.uvproj, settings and files
target K20D7 - Flash (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: USB_PHDC_MULTI
  c flags: Optim=1 wLevel=1
  c define: TWR_K20D72M
  c include: ..\kinetis_k20_72MHz;..\..\..\phdc_multi_specialization;..\..\..\common;..\..\..\common\kinetis;..\..\..\..\source\class;..\..\..\..\source\common;..\..\..\..\source\driver;..\..\..\..\source\driver\kinetis
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group StartUp
    ./: startup_MK20DX256VLL7.s system_MK20DX256VLL7.c
  group Documentation
    ./: Abstract.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
    ../../: usb_descriptor.c phd_com_model.c phd_device_spec.c phdc_app.c
  group classes
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_phdc.c
  group driver
    ../../../../source/common/: usb_framework.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
target K20D7 - RAM (ARM-ADS)
  device: MK20DX256xxx7 Freescale Semiconductor
  cpu: as above
  output: USB_PHDC_MULTI
  c flags: Optim=1 wLevel=1
  c define: TWR_K20D72M
  c include: as above
  memory RVCT4: ROM 0x1fff8000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
