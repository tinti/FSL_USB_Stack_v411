# IAR project USB_PHDC_MULTI.ewp, settings and files
configuration FLASH Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_MKL25Z128; LITTLE_ENDIAN
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_HID.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MKL25Z128xxx4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../../common/: main_kinetis.c
    ../../: phd_com_model.c phd_device_spec.c phdc_app.c usb_descriptor.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_phdc.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MKL25Z128xxx4.icf
  group startup
    ./: cstartup_M.s low_level_init.c
