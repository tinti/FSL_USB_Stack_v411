# IAR project USB_PRINTER.ewp, settings and files
configuration Flash Debug K40D7 (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256xxx7 Freescale MK40DX256xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K40D72M
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_PRINTER.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: D:\WORK\USB_Group\Project\USB Printer\Vss_Hai_20121021\Device\app\common\kinetis\iar_ew\MK40DX256VLL7_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../: printer.c usb_descriptor.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_printer.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK40DX256VLL7_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
