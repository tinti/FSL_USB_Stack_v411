<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_DFU.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_DFU</project>
        <configuration>Flash Debug K20D7</configuration>
      </member>      
    </batchDefinition>
  </batchBuild>
</workspace>


