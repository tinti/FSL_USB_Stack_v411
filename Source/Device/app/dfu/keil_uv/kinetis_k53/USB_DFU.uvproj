# Keil uVision project USB_DFU.uvproj, settings and files
target K53N512 - Flash (ARM-ADS)
  device: MK53N512CMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: USB_DFU
  c flags: Optim=1 wLevel=2
  c define: TWR_K53N512
  c include: ..\kinetis_k53;..\..\..\dfu;..\..\..\common;..\..\..\common\kinetis;..\..\..\..\source\class;..\..\..\..\source\common;..\..\..\..\source\driver;..\..\..\..\source\driver\kinetis
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ./: system_MK53N512CMD100.c startup_MK53N512CMD100.s
  group Documentation
    ./: Abstract.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
    ../../: dfu_mouse.c flash_FTFL.c usb_descriptor.c
  group classes
    ../../../../source/class/: usb_hid.c usb_dfu.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/common/: usb_framework.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
target K53N512 - RAM (ARM-ADS)
  device: MK52N512CMD100 Freescale Semiconductor
  cpu: as above
  output: USB_DFU
  c flags: Optim=1 wLevel=1
  c define: TWR_K53N512
  c include: as above
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
