# IAR project USB_MSD.ewp, settings and files
configuration Flash Debug K53 (ARM, debug)
  General.OGChipSelectEditMenu: K53Xxxx Freescale K53Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K53N512
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class; ..\..\kinetis_spi; ..\..\kinetis_sdhc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK53N512CMD100_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug K53 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK53N512CMD100_RAM.icf
  group (top)
    ../../: disk.c
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
    ../../kinetis_spi/: SD_kinetis.c SPI_kinetis.c
    ../../kinetis_sdhc/: SD_esdhc_kinetis.c esdhc_kinetis.c
    ../../: usb_descriptor.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_msc.c usb_msc_scsi.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK53N512CMD100_Flash.icf MK53N512CMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
