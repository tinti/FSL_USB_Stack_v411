# IAR project USB_MSD.ewp, settings and files
configuration Flash Debug K40D7 (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256xxx7 Freescale MK40DX256xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K40D72M
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class; ..\..\kinetis_spi
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK40DX256VLL7_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: disk.c
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
    ../../kinetis_spi/: SD_kinetis.c SPI_kinetis.c
    ../../: usb_descriptor.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_msc.c usb_msc_scsi.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK40DX256VLL7_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
