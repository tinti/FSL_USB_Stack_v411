# Keil uVision project USB_MSD.uvproj, settings and files
target K40N512 - Flash (ARM-ADS)
  device: MK40N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: USB_MSD
  c flags: Optim=1 wLevel=1
  c define: TWR_K40X256
  c include: ..\kinetis_k40;..\..\kinetis;..\..\..\msd;..\..\..\common;..\..\..\common\kinetis;..\..\..\..\source\class;..\..\..\..\source\common;..\..\..\..\source\driver;..\..\..\..\source\driver\kinetis
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ./: system_MK40N512VMD100.c startup_MK40N512VMD100.s
  group Documentation
    ./: Abstract.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
    ../../: usb_descriptor.c disk.c
    ../../kinetis_spi/: SD_kinetis.c SPI_kinetis.c
    ../../kinetis_sdhc/: SD_esdhc_kinetis.c esdhc_kinetis.c
  group classes
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_msc.c usb_msc_scsi.c
  group driver
    ../../../../source/common/: usb_framework.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
target K40N512 - RAM (ARM-ADS)
  device: MK40N512VMD100 Freescale Semiconductor
  cpu: as above
  output: USB_MSD
  c flags: Optim=1 wLevel=1
  c define: TWR_K40X256
  c include: as above
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
