<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_SD_BOOTLOADER.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_SD_BOOTLOADER</project>
        <configuration>Flash Debug K60</configuration>
      </member>      
      <member>
        <project>USB_SD_BOOTLOADER</project>
        <configuration>RAM Debug K60</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


