# Keil uVision project USB_BATT.uvproj, settings and files
target K60N512 - Flash (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: USB_BATT
  c flags: Optim=1 wLevel=1
  c define: TWR_K60N512
  c include: ..\kinetis_k60;..\..\..\batt_chg;..\..\..\common;..\..\..\common\kinetis;..\..\..\..\source\class;..\..\..\..\source\common;..\..\..\..\source\driver;..\..\..\..\source\driver\kinetis;..\..\kinetis;..\..\..\..\..\OTG\examples\common\kinetis;..\..\..\..\..\OTG\source\driver\max3353;..\..\..\..\..\OTG\source\otg_common;..\..\..\..\app\hid
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_MK60N512VMD100.s system_MK60N512VMD100.c
  group Documentation
    ./: Abstract.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c sci.c
    ../../: usb_batt_chg_app.c
    ../../../../source/driver/: usbevent.c
    ./: Retarget.c
    ../../../hid/: usb_descriptor.c
  group classes
    ../../../../source/class/: usb_batt_chg.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/common/: usb_framework.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
  group IIC
    ../../../../../OTG/examples/common/kinetis/: IIC_kinetis.c
  group max3353
    ../../../../../OTG/source/driver/max3353/: usb_otg_max3353_kinetis.c
target K60N512 - RAM (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: USB_MSD
  c flags: Optim=1 wLevel=1
  c define: TWR_K60N512
  c include: as above
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
