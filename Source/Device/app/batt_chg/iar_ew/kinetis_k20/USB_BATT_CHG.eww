<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_BATT_CHG.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_BATT_CHG</project>
        <configuration>Flash Debug K20</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


