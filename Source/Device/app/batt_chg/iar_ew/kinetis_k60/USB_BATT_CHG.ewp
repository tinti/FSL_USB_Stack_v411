# IAR project USB_BATT_CHG.ewp, settings and files
configuration Flash Debug K60 (ARM, debug)
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class; ..\..\..\..\app\hid; ..\..\..\..\..\OTG\examples\common\kinetis; ..\..\..\..\..\OTG\source\driver\max3353; ..\..\..\..\..\OTG\source\otg_common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_BATT_CHG.srec
  ILINK.IlinkOutputFile: USB_BATT_CHG.out
  ILINK.IlinkIcfFile: config\MK60N512VMD100_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug K60 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LITTLE_ENDIAN
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\MK60N512VMD100_RAM.icf
  group (top)
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: printf.c RealTimerCounter_kinetis.c sci.c wdt_kinetis.c
    ../../: usb_batt_chg_app.c
  group batt_chg
    ../../../../source/class/: usb_batt_chg.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_hid.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c usbevent.c
    ../../../../source/common/: usb_framework.c
  group IIC
    ../../../../../OTG/examples/common/kinetis/: IIC_kinetis.c
  group max3353
    ../../../../../OTG/source/driver/max3353/: usb_otg_max3353_kinetis.c
  group prm
    config/: MK60N512VMD100_Flash.icf MK60N512VMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
