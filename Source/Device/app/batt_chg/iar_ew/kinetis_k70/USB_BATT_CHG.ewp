# IAR project USB_BATT_CHG.ewp, settings and files
configuration Flash Debug K70 (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K70FN1M0
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\driver\kinetis\usbhs; ..\..\..\..\source\common; ..\..\..\..\source\class; ..\..\..\..\..\OTG\examples\common\kinetis; ..\..\..\..\..\OTG\source\driver\max3353; ..\..\..\..\..\OTG\source\otg_common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK70FN1M0_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug K70 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCDefines: TWR_K60N512
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK60N512VMD100_RAM.icf
  group (top)
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: printf.c RealTimerCounter_kinetis.c sci.c wdt_kinetis.c
    ../../: usb_batt_chg_app.c usb_descriptor.c
    ../../../../source/driver/: usbevent.c
  group class
    ../../../../source/class/: usb_batt_chg.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group IIC
    ../../../../../OTG/examples/common/kinetis/: IIC_kinetis.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK70FN1M0_Flash.icf MK70FN1M0_RAM.icf
  group max3353
    ../../../../../OTG/source/driver/max3353/: usb_otg_max3353_kinetis.c
  group startup
    ./: cstartup_M.s low_level_init.c
