<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_HID.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_HID</project>
        <configuration>Flash Debug K70</configuration>
      </member>
      <member>
        <project>USB_HID</project>
        <configuration>RAM Debug K70</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


