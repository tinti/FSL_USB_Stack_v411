# IAR project USB_HID.ewp, settings and files
configuration Flash Debug K20D7 (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256xxx7 Freescale MK20DX256xxx7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K20D72M
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_HID.srec
  ILINK.IlinkOutputFile: USB_HID.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK20DX256VLL7_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../: mouse_button.c usb_descriptor.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_hid.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK20DX256VLL7_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
