# IAR project USB_CDC.ewp, settings and files
configuration Flash Debug K20 (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX128xxx5 Freescale MK20DX128xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K20X128
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK20DX128VLH5_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
    ../../: usb_descriptor.c virtual_com.c
  group class
    ../../../../source/class/: usb_cdc.c usb_cdc_pstn.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK20DX128VLH5_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
