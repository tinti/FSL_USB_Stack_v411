<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_AUDIO_SPK.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_AUDIO_SPK</project>
        <configuration>Flash Debug K70</configuration>
      </member>
      <member>
        <project>USB_AUDIO_SPK</project>
        <configuration>RAM Debug K70</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


