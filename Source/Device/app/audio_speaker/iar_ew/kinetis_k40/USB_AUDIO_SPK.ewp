# IAR project USB_AUDIO_SPK.ewp, settings and files
configuration Flash Debug K40 (ARM, debug)
  General.OGChipSelectEditMenu: K40Xxxx Freescale K40Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K40X256
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK40N512VMD100_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug K40 (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK40N512VMD100_Flash.icf
  group (top)
    ./: readme.txt
  group app
    ../../: audio_pit1_kinetis.c audio_pwm_kinetis.c audio_speaker.c usb_descriptor.c
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: printf.c sci.c wdt_kinetis.c
  group class
    ../../../../source/class/: usb_audio.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK40N512VMD100_Flash.icf MK40N512VMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
