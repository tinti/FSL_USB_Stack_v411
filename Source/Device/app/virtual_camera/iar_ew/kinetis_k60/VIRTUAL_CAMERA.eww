<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\VIRTUAL_CAMERA.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>VIRTUAL_CAMERA</project>
        <configuration>Flash Debug K60</configuration>
      </member>      
      <member>
        <project>VIRTUAL_CAMERA</project>
        <configuration>RAM Debug K60</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


