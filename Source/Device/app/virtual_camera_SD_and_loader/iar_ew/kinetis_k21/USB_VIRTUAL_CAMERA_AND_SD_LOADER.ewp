# IAR project USB_VIRTUAL_CAMERA_AND_SD_LOADER.ewp, settings and files
configuration Flash Debug K21 (ARM, debug)
  General.OGChipSelectEditMenu: MK21DN512xxx5 Freescale MK21DN512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K21D50M
  ICCARM.CCIncludePath2: ; ..\..\sd_driver\kinetis; ..\..\kinetis; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_VIRTUAL_CAMERA_AND_SD_LOADER.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK21DN512VL_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    ../../: FAT16.c usb_descriptor.c Virtual_camera_SD.c write_sd_data.c
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: printf.c RealTimerCounter_kinetis.c sci.c wdt_kinetis.c
  group app/sd_driver
    ../../sd_driver/kinetis/: SD_kinetis.c SPI_kinetis.c
  group class
    ../../../../source/common/: usb_class.c
    ../../../../source/class/: usb_msc.c usb_msc_scsi.c usb_video.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK21DN512VL_Flash.icf
  group startup
    ./: cstartup_M.s low_level_init.c
