<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_VIRTUAL_CAMERA_AND_SD_LOADER.ewp</path>
  </project>
  <batchBuild/>
</workspace>


