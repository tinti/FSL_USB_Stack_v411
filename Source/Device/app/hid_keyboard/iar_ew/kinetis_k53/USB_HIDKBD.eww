<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_HIDKBD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_HIDKBD</project>
        <configuration>Flash Debug K53</configuration>
      </member>      
      <member>
        <project>USB_HIDKBD</project>
        <configuration>RAM Debug K53</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


