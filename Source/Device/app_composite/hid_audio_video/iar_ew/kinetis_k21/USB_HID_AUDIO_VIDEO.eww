<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_HID_AUDIO_VIDEO.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>USB_HID_AUDIO_VIDEO</project>
        <configuration>Flash Debug K21</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


