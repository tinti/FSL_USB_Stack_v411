# IAR project USB_HID_AUDIO_VIDEO.ewp, settings and files
configuration Flash Debug K60 (ARM, debug)
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K60N512; LITTLE_ENDIAN
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_HID_AUDIO_VIDEO.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK60N512VMD100_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: readme.txt
  group app
    ../../: audio_pit1_kinetis.c audio_pwm_kinetis.c audio_speaker.c composite_app.c mouse_button.c usb_descriptor.c video_data_kinetis_audio_solution.c virtual_camera.c
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: printf.c RealTimerCounter_kinetis.c sci.c wdt_kinetis.c
  group class
    ../../../../source/class/: usb_audio.c usb_composite.c usb_hid.c usb_video.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK60N512VMD100_Flash.icf MK60N512VMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
