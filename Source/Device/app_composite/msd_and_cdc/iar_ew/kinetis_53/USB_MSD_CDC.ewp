# IAR project USB_MSD_CDC.ewp, settings and files
configuration Flash Debug K53 (ARM, debug)
  General.OGChipSelectEditMenu: K53Xxxx Freescale K53Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TWR_K53N512
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\kinetis; ..\..\..\common; ..\..\..\common\kinetis; ..\..\..\..\source\driver; ..\..\..\..\source\driver\kinetis; ..\..\..\..\source\common; ..\..\..\..\source\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK53N512CMD100_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug K53 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: USB_MSD.srec
  ILINK.IlinkIcfFile: ..\..\..\common\kinetis\iar_ew\MK53N512CMD100_RAM.icf
  group (top)
    ./: readme.txt
  group app
    ../../: composite_app.c disk.c FAT16.c inf_data.c usb_descriptor.c virtual_com.c
    ../../../common/: main_kinetis.c
    ../../../common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
  group class
    ../../../../source/class/: usb_cdc.c usb_cdc_pstn.c usb_composite.c usb_msc.c usb_msc_scsi.c
    ../../../../source/common/: usb_class.c
  group driver
    ../../../../source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../source/driver/: usb_driver.c
    ../../../../source/common/: usb_framework.c
  group linker config
    ../../../common/kinetis/iar_ew/: MK53N512CMD100_Flash.icf MK53N512CMD100_RAM.icf
  group startup
    ./: cstartup_M.s low_level_init.c
