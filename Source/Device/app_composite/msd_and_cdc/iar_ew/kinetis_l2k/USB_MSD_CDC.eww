<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\Host\examples\hid\keyboard\iar_ew\kinetis_kl25\USBH_HIDKBD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


