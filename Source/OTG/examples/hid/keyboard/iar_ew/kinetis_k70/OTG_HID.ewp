# IAR project OTG_HID.ewp, settings and files
configuration Flash Debug K70 (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: TWR_K70FN1M0; LITTLE_ENDIAN; A_DEBUG; OTG_BUILD=1; USER_CONFIG_BAUDRATE=19200
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\..\..\source\otg_common; ..\..\..\..\..\source\otg_common\kinetis; ..\..\..\..\..\source\driver\max3353; ..\..\..\..\..\source\driver\usb3300; ..\..\..\..\..\..\Device; ..\..\..\..\..\..\Device\app\common\kinetis; ..\..\..\..\..\..\Device\source\driver\kinetis; ..\..\..\..\..\..\Device\source\driver; ..\..\..\..\..\..\Device\source\common; ..\..\..\..\..\..\Device\source\class; ..\..\..\..\..\..\Host; ..\..\..\..\..\..\Host\examples\common; ..\..\..\..\..\..\Host\examples\common\kinetis; ..\..\..\..\..\..\Host\source\host_common; ..\..\..\..\..\..\Host\source\driver; ..\..\..\..\..\..\Host\source\driver\kinetis\ehci; ..\..\..\..\..\..\Host\source\classes\hid; ..\..\..\..\..\..\Host\source\classes\hub
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\common\kinetis\iar_ew\MK70FN1M0_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug K70 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K70Xxxx Freescale K70Xxxx
  ICCARM.CCDefines: TWR_K70FN1M0; A_DEBUG; LITTLE_ENDIAN; OTG_BUILD=1; USER_CONFIG_BAUDRATE=19200
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\..\..\source\otg_common; ..\..\..\..\..\source\otg_common\kinetis; ..\..\..\..\..\source\driver\max3353; ..\..\..\..\..\..\Device; ..\..\..\..\..\..\Device\app\common\kinetis; ..\..\..\..\..\..\Device\source\driver\kinetis; ..\..\..\..\..\..\Device\source\driver; ..\..\..\..\..\..\Device\source\common; ..\..\..\..\..\..\Device\source\class; ..\..\..\..\..\..\Host; ..\..\..\..\..\..\Host\examples\common; ..\..\..\..\..\..\Host\examples\common\kinetis; ..\..\..\..\..\..\Host\source\host_common; ..\..\..\..\..\..\Host\source\driver; ..\..\..\..\..\..\Host\source\classes\hid; ..\..\..\..\..\..\Host\source\classes\hub
  ILINK.IlinkIcfFile: ..\..\..\..\common\kinetis\iar_ew\MK70FN1M0_RAM.icf
  group (top)
    ./: readme.txt
  group app
    ../../: keyboard_dev_kinetis.c keyboard_host.c keyboard_otg_kinetis.c usb_descriptor.c
    ../../../../../../Host/examples/common/: poll.c
  group app/common
    ../../../../../../Host/examples/common/kinetis/: IIC_kinetis.c PIT1_kinetis.c printf.c sci_kinetis.c
    ../../../../../../Device/app/common/kinetis/: RealTimerCounter_kinetis.c wdt_kinetis.c
  group bsp/P3
    ../../../../../source/bsp/P3/: P3.c
  group device/class
    ../../../../../../Device/source/common/: usb_class.c
    ../../../../../../Device/source/class/: usb_hid.c
  group device/usb_driver
    ../../../../../../Device/source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../../../Device/source/driver/: usb_driver.c
    ../../../../../../Device/source/common/: usb_framework.c
  group host/classes
    ../../../../../../Host/source/classes/common/: usb_classes.c
  group host/classes/hid
    ../../../../../../Host/source/classes/hid/: usb_host_hid.c
  group host/classes/hub
    ../../../../../../Host/source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
  group host/driver
    ../../../../../../Host/source/driver/: mem_util.c usbevent.c usbmsgq.c usbsem.c
  group host/driver/ehci
    ../../../../../../Host/source/driver/kinetis/ehci/: ehci_bw.c ehci_cncl.c ehci_intr.c ehci_iso.c ehci_main.c ehci_shut.c ehci_utl.c
  group host/driver/khci
    ../../../../../../Host/source/driver/kinetis/: khci_kinetis.c
  group host/host_common
    ../../../../../../Host/source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group linker config
    ../../../../common/kinetis/iar_ew/: MK70FN1M0_Flash.icf MK70FN1M0_RAM.icf
  group otg_common
    ../../../../../source/otg_common/: usb_otg_sm_a_kinetis.c usb_otg_sm_b.c usb_otg_sm_main.c
  group otg_driver/kinetis
    ../../../../../source/driver/otg_usb_fs/kinetis/: usb_otg_fs_a_dev.c usb_otg_fs_b_dev.c usb_otg_fs_main.c
  group otg_driver/max3353
    ../../../../../source/driver/max3353/: usb_otg_max3353_kinetis.c
  group otg_driver/usb3300
    ../../../../../source/driver/usb3300/: usb3300.c usb3300.h
  group startup
    ./: cstartup_M.s low_level_init.c
