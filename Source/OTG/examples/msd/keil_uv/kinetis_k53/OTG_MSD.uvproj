# Keil uVision project OTG_MSD.uvproj, settings and files
target K53N512 - Flash (ARM-ADS)
  device: MK53N512CMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: OTG_MSD
  c flags: Optim=1 wLevel=1
  c define: LITTLE_ENDIAN,USER_CONFIG_BAUDRATE=115200,A_DEBUG,OTG_BUILD=1
  c include: ..\kinetis_k53;..\..\..\msd;..\..\..\..\..\Host\source\classes\common;..\..\..\..\..\Host\source\classes\msd;..\..\..\..\..\Host\source\classes\hub;..\..\..\..\..\Host\source\driver;..\..\..\..\..\Host\source\driver\kinetis;..\..\..\..\..\Host\source\host_common;..\..\..\..\..\Host\examples\msd;..\..\..\..\..\Host\examples\common;..\..\..\..\..\Host\examples\common\kinetis;..\..\..\..\..\Device\source\class;..\..\..\..\..\Device\source\common;..\..\..\..\..\Device\source\driver;..\..\..\..\..\Device\source\driver\kinetis;..\..\..\..\..\Device\app\common\kinetis;..\..\..\..\source\otg_common;..\..\..\..\source\driver\max3353;..\..\kinetis
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group StartUp
    ./: system_MK53N512CMD100.c startup_MK53N512CMD100.s
  group Documentation
    ./: Abstract.txt
  group app
    ../../: usb_descriptor.c msd_dev_kinetis.c msd_host.c msd_otg.c
    ./: Retarget.c
    ../../kinetis/: SD_kinetis.c SPI_kinetis.c
    ../../../../../Host/examples/common/: poll.c
    ../../../../../Host/examples/common/kinetis/: IIC_kinetis.c PIT1_kinetis.c sci_kinetis.c
    ../../../../../Device/app/common/kinetis/: wdt_kinetis.c RealTimerCounter_kinetis.c
  group bsp
    ../../../../source/bsp/P2/: P2.c
  group device_class
    ../../../../../Device/source/common/: usb_class.c
    ../../../../../Device/source/class/: usb_msc_scsi.c usb_msc.c
  group device_driver
    ../../../../../Device/source/driver/: usb_driver.c
    ../../../../../Device/source/driver/kinetis/: usb_dci_kinetis.c
    ../../../../../Device/source/common/: usb_framework.c
  group host_classes
    ../../../../../Host/source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
    ../../../../../Host/source/classes/common/: usb_classes.c
    ../../../../../Host/source/classes/msd/: usb_host_msd_ufi.c usb_host_msd_queue.c usb_host_msd_bo.c
  group host_common
    ../../../../../Host/source/host_common/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_driver.c host_main.c host_rcv.c host_shut.c host_snd.c
  group host_driver
    ../../../../../Host/source/driver/kinetis/: khci_kinetis.c
    ../../../../../Host/source/driver/: mem_util.c usbevent.c usbsem.c usbmsgq.c
  group otg_common
    ../../../../source/otg_common/: usb_otg_sm_a_kinetis.c usb_otg_sm_b.c usb_otg_sm_main.c
  group otg_driver_kinetis
    ../../../../source/driver/otg_usb_fs/kinetis/: usb_otg_fs_a_dev.c usb_otg_fs_b_dev.c usb_otg_fs_main.c
  group otg_driver_max3353
    ../../../../source/driver/max3353/: usb_otg_max3353_kinetis.c
target K53N512 - RAM (ARM-ADS)
  device: MK53N512CMD100 Freescale Semiconductor
  cpu: as above
  output: OTG_MSD
  c flags: Optim=1 wLevel=1
  c define: as above
  c include: as above
  memory RVCT4: ROM 0x1fff0000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
